## chromeos/drivers/Kconfig
```kconfig
menu "Chromeos Supplied Third-Party Device Drivers"

source "chromeos/drivers/gobi/Kconfig"
source "chromeos/drivers/nvidia/Kconfig"

endmenu
```
